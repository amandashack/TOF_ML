* Auto-generated netlist for an LTspice simulation

V1 n001 0 0.0
R1 n001 n002 3.08k
R2 n002 n003 2.43k
R3 n003 n004 1.75k
R4 n004 n005 1.25k
R5 n005 n006 0.897k
R6 n006 n007 0.664k
R7 n007 n008 0.528k
R8 n008 n009 0.446k
R9 n009 n010 0.457k
R10 n010 n011 0.483k
R11 n011 n012 0.528k
R12 n012 n013 0.577k
R13 n013 n014 0.621k
R14 n014 n015 0.65k
R15 n015 n016 0.657k
R16 n016 n017 0.639k
R17 n017 n018 0.593k
R18 n018 n019 0.52k
R19 n019 n020 0.422k
R20 n020 n021 0.305k
R21 n021 n022 0.178k
R22 n022 n023 0.048k
R23 n023 n024 0.072k
R24 n024 n025 0.167k
R25 n025 n026 0.22k
R26 n026 n027 2.13k
V2 n002 0 -3.0847617220560855
V3 n003 0 -5.518518535236697
V4 n004 0 -7.271224059132201
V5 n005 0 -8.523156576200417
V6 n006 0 -9.42154335044857
V7 n007 0 -10.086569903515205
V8 n008 0 -10.61538619872482
V9 n009 0 -11.06207572081476
V10 n010 0 -11.519782249054902
V11 n011 0 -12.00352897365006
V12 n012 0 -12.532345268859675
V13 n013 0 -13.110237318738365
V14 n014 0 -13.732197393217854
V15 n015 0 -14.383202302093329
V16 n016 0 -15.041218033064382
V17 n017 0 -15.681205935789652
V18 n018 0 -16.275122721886813
V19 n019 0 -16.79592664898719
V20 n020 0 -17.21857906674942
V21 n021 0 -17.524050600914066
V22 n022 0 -18
V23 n023 0 -17.7504
V24 n024 0 -17.67849411764706
V25 n025 0 -17.511712418300654
V26 n026 0 -17.292
V27 n027 0 0.0
V28 n028 0 -20.0
V29 n029 0 -20.0
V30 n030 0 0.0
V31 n031 0 0.0
V32 n032 0 -20.0
V33 n033 0 -20.0
V34 n034 0 280.0
V35 n035 0 0.0
V36 n036 0 0.0
V37 n037 0 0.0

.op
.end
