* Auto-generated netlist for an LTspice simulation

R1 0 N003 3.08Meg
R2 N003 N004 2.43Meg
R3 N004 N005 1.75Meg
R4 N005 N006 1.25Meg
R5 N006 N007 0.897Meg
R6 N007 N008 0.664Meg
R7 N008 N009 0.528Meg
R8 N009 N010 0.446Meg
R9 N010 N011 0.457Meg
R10 N011 N012 0.483Meg
R11 N012 N013 0.528Meg
R12 N013 N014 0.577Meg
R13 N014 N015 0.621Meg
R14 N015 N016 0.65Meg
R15 N016 N017 0.657Meg
R16 N017 N018 0.639Meg
R17 N018 N019 0.593Meg
R18 N019 N020 0.52Meg
R19 N020 N021 0.422Meg
R20 N021 N022 0.305Meg
R21 N022 N023 0.178Meg
R22 N023 N001 0.048Meg
R23 N001 N024 0.072Meg
R25 N025 N002 0.22Meg
R26 N026 N002 2.13Meg
V22 0 N001 44.376
V25 0 N002 43.230000000000004
V1 0 N026 50.0

.op
.end
